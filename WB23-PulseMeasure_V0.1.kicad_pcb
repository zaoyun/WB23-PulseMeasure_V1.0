# Repository zaoyun/WB23-PulseMeasure_V1.0

## KiCad design WB23-PulseMeasure_V0.1.kicad_pcb

Parts:
C1, C4: 20pF; C_0603_1608Metric
C2, C3, C9, C10, C11, C16, C18, C20, C23: 0.1uf; C_0603_1608Metric
C5: 220nF; C_0603_1608Metric
C6, C12, C14: 1uF; C_0603_1608Metric
C7: 0.1uF; C_0603_1608Metric
C8: 10nF; C_0603_1608Metric
C13, C24: 2.2uF; C_0603_1608Metric
C15, C17, C19, C22: 10uf; C_0603_1608Metric
C21, C25: 10uF; C_0603_1608Metric
D1, D2, D3, D4: RED; D_0402_1005Metric
J1: SWD; PinHeader_1x04_P1.27mm_Vertical
J2: Sensor; PinHeader_1x02_P1.27mm_Vertical
J5: Power; PinSocket_1x02_P2.54mm_Vertical
J6: Conn_01x02; PinHeader_1x02_P1.27mm_Vertical
JP1: connector; PinHeader_1x03_P1.27mm_Vertical
R1, R2, R5, R10, R11, R12, R20, R24: 10K; R_0603_1608Metric
R3, R4, R26, R28, R29, R30, R31: 10k; R_0603_1608Metric
R6, R8, R27: 2K; R_0603_1608Metric
R7: 10M; R_0603_1608Metric
R9, R15: 0R; R_0603_1608Metric
R13, R16: 3K; R_0603_1608Metric
R14: 1.5k; R_0603_1608Metric
R17, R21, R22, R25: 1K; R_0603_1608Metric
R18: 6.8K; R_0603_1608Metric
R19: 15R; R_0603_1608Metric
R23: 62K; R_0603_1608Metric
R32: 1k; R_0603_1608Metric
U1: JDY-23
U2: STM32F373C8Tx; LQFP-48_7x7mm_P0.5mm
U3, U4: TLC274; SOIC127P600X175-14N
V1: AMS1117-5.0; SOT-223-3_TabPin2
V2: HT7533; SOT-89-3
V3: REF3025; SOT-23
VR1: 20K; RES-ADJ-SMD_EVM3ESX50B24; PARTREV 05/16
Y1: 8M; XTAL_NX3225GD-8MHZ-STD-CRA-3

Connections:
+3.3V: C2.2, C9.2, C10.2, C11.2, C19.2, C20.2, J1.4, R1.2, R10.2, R11.2, R12.2, U1.1 (VCC), U2.9 (VDDA), U2.17 (VDD), U2.24 (VDDSD), U2.48 (VDD), V2.3 (VOUT), V3.1 (IN)
+5V: C17.2, C18.2, R15.2, V1.2 (VO), V2.2 (VIN)
+12V: C15.2, C16.2, J5.1, V1.3 (VI)
/ADC: R9.1, U2.20 (PB2), U4.1, U4.3 (+)
/ADC1_IN9: R9.2, U2.19 (PB1)
/BOOT0: R2.1, U2.44 (BOOT0)
/DAC: R21.1, R22.1, U2.14 (PA4)
/IN+: C6.1, J2.2, R3.2, R4.1, R8.2, R17.2, R19.2
/IN-: C5.2, C8.2, J2.1
/JDY-23_PWRC: U1.22 (PWRC), U2.41 (PB5)
/JDY-23_STAT: U1.6 (STAT), U2.35 (PF6)
/LED1: D2.1 (K), U2.2 (PC13)
/LED2: D3.1 (K), U2.3 (PC14)
/LED3: D4.1 (K), U2.4 (PC15)
/NRST: C3.2, R1.1, U2.7 (NRST)
/OUT: JP1.1, R23.1, R25.2, R28.2, U3.1
/REF2V5: C22.2, C23.2, U2.25 (VREFSD+), V3.2 (OUT)
/SWCLK: J1.3, U2.37 (PA14)
/SWDIO: J1.1, U2.34 (PA13)
/USART1_RX_JDY-23_TX: U1.19 (TXD), U2.31 (PA10)
/USART1_TX_JDY-23_RX: U1.20 (RXD), U2.30 (PA9)
/USART3_RX: J6.1, U2.46 (PB9)
/USART3_TX: J6.2, U2.28 (PD8)
/X1: C1.2, U2.5 (PF0), Y1.1
/X2: C4.2, U2.6 (PF1), Y1.2
GND: C1.1, C2.1, C3.1, C4.1, C6.2, C9.1, C10.1, C11.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.2, C22.1, C23.1, C24.2, C25.2, D1.1 (K), J1.2, J5.2, JP1.2, R2.2, R4.2, R20.1, R27.2, R29.1, U1.24 (GND), U2.8 (VSSA), U2.23 (VSSSD), U2.47 (VSS), U3.11 (V-), U4.11 (V-), V1.1 (GND), V2.1 (GND), V3.3 (GND), VR1.3
unnamed: C5.1, C7.2, R6.2, R7.2
unnamed: C7.1, R6.1, U3.9 (-)
unnamed: C12.1, C14.2, R14.1
unnamed: C8.1, C12.2, R7.1, R13.2, U3.8
unnamed: C13.1, R13.1, R16.2
unnamed: C13.2, R14.2, U3.13 (-), U3.14
unnamed: C14.1, R16.1, U3.5 (+)
unnamed: C24.1, R26.1, R27.1, U4.10 (+), VR1.2
unnamed: D1.2 (A), R5.1
unnamed: D2.2 (A), R10.1
unnamed: D3.2 (A), R11.1
unnamed: D4.2 (A), R12.1
unnamed: R5.2, U1.17 (ALED)
unnamed: R8.1, U3.10 (+)
unnamed: R17.1, R23.2, U3.2 (-)
unnamed: R18.1, U3.3 (+), U3.6 (-), U3.7
unnamed: R18.2, R19.1, U3.12 (+)
unnamed: R20.2, R24.1, U4.13 (-)
unnamed: R21.2, U4.12 (+)
unnamed: R22.2, R24.2, R25.1, U4.14
unnamed: R28.1, R29.2, U4.5 (+)
unnamed: R30.1, R31.2, U4.6 (-)
unnamed: R30.2, U4.8, U4.9 (-)
unnamed: R31.1, R32.2, U4.7
unnamed: R32.1, U4.2 (-)
VCC: C21.1, C25.1, JP1.3, R3.1, R15.1, R26.2, U3.4 (V+), U4.4 (V+), VR1.1

Notes on the sheet:
减掉偏置电压
不放大时焊上
DAC模拟脉博信号
16bit 50ksps最高采样率
兼容12b、16b
MCU
Serial
如透传下不需要低功耗，或在连接状态下不需要发断开指令，PWRC可不接。 如不需要检测连接状态，STAT可不接。
BlueTooth
Power
实际拆除

Board: 2 copper layers, 53.3 x 20.3 mm, 75 parts (28 on the bottom side), 52 nets.
